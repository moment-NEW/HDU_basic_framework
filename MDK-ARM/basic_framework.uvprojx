# Keil uVision project basic_framework.uvprojx, settings and files
target basic_framework (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: basic_framework +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,STM32F407xx
  c include: ..\application\**;..\bsp\**;../Inc;..\modules\**;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;..\application\chassis;..\application\gimbal;..\application\shoot;..\application\cmd;..\bsp\adc;..\bsp\can;..\bsp\dwt;..\bsp\flash;..\bsp\gpio;..\bsp\iic;..\bsp\log;..\bsp\pwm;..\bsp\spi;..\bsp\usart;..\bsp\usb;..\modules\alarm;..\modules\algorithm;..\modules\bluetooth;..\modules\BMI088;..\modules\can_comm;..\modules\daemon;..\modules\encoder;..\modules\imu;..\modules\ist8310;..\modules\master_machine;..\modules\message_center;..\modules\motor;..\modules\oled;..\modules\referee;..\modules\remote;..\modules\standard_cmd;..\modules\super_cap;..\modules\TFminiPlus;..\modules\unicomm;..\modules\motor\DJImotor;..\modules\motor\DMmotor;..\modules\motor\HTmotor;..\modules\motor\LKmotor;..\modules\motor\servo_motor;..\modules\motor\step_motor;..\application;..\bsp;..\modules;..\Middlewares\Third_Party\SEGGER\RTT;..\Middlewares\Third_Party\FreeRTOS;..\MDK-ARM;..\Middlewares\Third_Party\SEGGER\Config
  asm include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c crc.c dac.c dma.c i2c.c rng.c rtc.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
  group Apps
    ../application/: application.md APP层应用编写指引.md robot.c robot.h robot_def.h robot_task.h
  group chassis
    ../application/chassis/: balance.h chassis.c chassis.h chassis.md mecanum.h steering.h
  group cmd
    ../application/cmd/: robot_cmd.c robot_cmd.h robot_cmd.md
  group gimbal
    ../application/gimbal/: gimbal.c gimbal.h gimbal.md
  group shoot
    ../application/shoot/: shoot.c shoot.h shoot.md
  group bsp
    ../bsp/: bsp.md bsp_init.h bsp_tools.c bsp_tools.h
  group bsp_device
    ../bsp/adc/: bsp_adc.c bsp_adc.h bsp_adc.md
    ../bsp/can/: bsp_can.c bsp_can.h bsp_can.md
    ../bsp/dwt/: bsp_dwt.c bsp_dwt.h bsp_dwt.md
    ../bsp/flash/: bsp_flash.c bsp_flash.h bsp_flash.md
    ../bsp/gpio/: bsp_gpio.c bsp_gpio.h bsp_gpio.md
    ../bsp/iic/: bsp_iic.c bsp_iic.h bsp_iic.md
    ../bsp/log/: bsp_log.c bsp_log.h bsp_log.md
    ../bsp/pwm/: bsp_pwm.c bsp_pwm.h bsp_pwm.md
    ../bsp/spi/: bsp_spi.c bsp_spi.h bsp_spi.md
    ../bsp/usart/: bsp_usart.c bsp_usart.h bsp_usart.md
    ../bsp/usb/: bsp_usb.c bsp_usb.h bsp_usb.md
    ./: memory.h
  group Modules
    ../modules/: general_def.h module.md
  group Modules_devices
    ../modules/alarm/: buzzer.c buzzer.h buzzer.md
    ../modules/algorithm/: algorithm.md controller.c controller.h crc8.c crc8.h crc16.c crc16.h kalman_filter.c kalman_filter.h QuaternionEKF.c QuaternionEKF.h user_lib.c user_lib.h
    ../modules/bluetooth/: HC05.c HC05.h
    ../modules/BMI088/: bmi088.c bmi088.h bmi088.md bmi088_regNdef.h
    ../modules/can_comm/: can_comm.c can_comm.h can_comm.md
    ../modules/daemon/: daemon.c daemon.h daemon.md
    ../modules/encoder/: encoder.md
    ../modules/imu/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h ins_task.c ins_task.h ins_task.md
    ../modules/ist8310/: ist8310.c ist8310.h ist8310.md
    ../modules/master_machine/: master_process.c master_process.h master_process.md seasky_protocol.c seasky_protocol.h 湖南大学RoboMaster电控组通信协议.md
    ../modules/message_center/: message_center.c message_center.h message_center.md
    ../modules/motor/: motor_def.h motor_task.c motor_task.h
    ../modules/oled/: oled.c oled.h oled.md oledfont.h
    ../modules/referee/: crc_ref.c crc_ref.h referee.md referee_protocol.h referee_task.c referee_task.h referee_UI.c referee_UI.h rm_referee.c rm_referee.h
    ../modules/remote/: remote.md remote_control.c remote_control.h
    ../modules/standard_cmd/: standard_cmd.md std_cmd.c std_cmd.h
    ../modules/super_cap/: super_cap.c super_cap.h super_cap.md
    ../modules/TFminiPlus/: tfminiplus.c tfminiplus.h tfminiplus.md
    ../modules/unicomm/: unicomm.c unicomm.h unicomm.md
  group Motors
    ../modules/motor/DJImotor/: dji_motor.c dji_motor.h dji_motor.md
    ../modules/motor/DMmotor/: dmmotor.c dmmotor.h
    ../modules/motor/HTmotor/: HT04.c HT04.h HT04.md
    ../modules/motor/LKmotor/: LK_motor.md LK9025.c LK9025.h
    ../modules/motor/servo_motor/: servo_motor.c servo_motor.h servo_motor.md
    ../modules/motor/step_motor/: step_motor.c step_motor.h
  group SEGGER
    ../Middlewares/Third_Party/SEGGER/Config/: SEGGER_RTT_Conf.h
    ../Middlewares/Third_Party/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
